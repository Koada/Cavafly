# Keil uVision project Template.uvproj, settings and files
target Cava (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Usr;..\..\Lib\CM3;..\..\Lib\inc;..\..\Usr\core;..\..\Usr\core\algorithms;..\..\Usr\core\clock;..\..\Usr\core\sensors;..\..\Usr\debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../Lib/CM3/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group PERIPH
    ../../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
  group USR
    ../../Usr/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../Usr/core/: globals.h globals.c
  group CLOCK
    ../../Usr/core/clock/: sample.h sample.c control.h control.c motors.h motors.c
  group SENSORS
    ../../Usr/core/sensors/: I2C.c MPU6050.c MPU6050.h I2C.h
  group ALGORITHMS
    ../../Usr/core/algorithms/: AHRS.h AHRS.c filter.h filter.c PID.h PID.c
  group DEBUG
    ../../Usr/debug/: show_char.c show_char.h
  group REMOTE
    ../../Usr/: wireless.h wireless.c
